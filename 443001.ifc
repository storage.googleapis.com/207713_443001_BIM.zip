Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-19T18:15:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 19 18:15:18 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{1AB96896-5FC7-455B-A026-E17FF3BD90C1}\ifc * Database version: 5507 * Database creation date: Thu Aug 19 18:15:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 19 18:15:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 19 18:15:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 443001 Remote sensor, L=2000, 443001(2021):443001 Remote sensor, L=2000:424227
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - SensorNominalDepth: 57.9493 mm; SensorNominalHeight: 164.501 mm; SensorNominalWidth: 51.9789 mm; ThermostatNominalDepth: 85.676 mm; ThermostatNominalHeight: 54.499 mm; ThermostatNominalWidth: 54.4959 mm
Type - General - Author: BIMstone; BIMObjectName: 443001(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_75_50_76; Uniclass2015Description: Sensors and detectors; Uniclass2015Reference: Pr_75_50_76; Version: 1; VersionDate: 05/08/2021
Type - Green Building Properties - Customs Code: 84818031; EAN Number: 6414150098116; EN Standard: EN 215; LVI Number: 4032047
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/443001; Catalog Drawing URL: http://static.oras.com/catdrw/443001; Dimension Drawing URL: http://static.oras.com/dimdrw/443001; FDV Document URL: http://www.oras.com/datasheet/443001/en/fdv; Group: RadiatorValve; Manufacturer: Oras; Model: 443001 Remote sensor, L=2000; Name_en: 443001 Remote sensor, L=2000; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 0.209 kg; Product Code: 443001; Product Datasheet: http://www.oras.com/datasheet/443001/en; Product Family: Oras; Product Image URL: http://static.oras.com/image/443001; Product URL: http://static.oras.com/443001; Technical DataSheet URL: http://www.oras.com/datasheet/443001/en; Type Name: 443001 Remote sensor, L=2000
Type - Materials and Finishes - ThermostatMainMaterial: Fine Textured - White
Type - Mechanical - Installation and Maintenance: http://static.oras.com/manual/443001; Temperature: Thermostatic temperature control
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Technical room; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 443001(2021); Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 443001; Name: 443001 Remote sensor, L=2000; ReplacementCost: n/a; Shape: Sculptured; Size: Thermostat: 55x85x55 mm; Sensor:55x60x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 443001; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 443001 Remote sensor, L=2000
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm; SensorDefaultElevation: 900 mm; SensorVisibility: yes; ThermostatDefaulElevation: 900 mm
Dimensions - Area: 0.034405 m2; ConnectorDirection: 1; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 90 deg; Volume: 0.000756141 m3
Identity Data - Mark: 2
Mechanical - System Classification: Hydronic Supply
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 443001(2021): 443001 Remote sensor, L=2000; Family and Type: 443001(2021): 443001 Remote sensor, L=2000; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 443001(2021): 443001 Remote sensor, L=2000; Type Id: 443001(2021): 443001 Remote sensor, L=2000; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
